# Allegro board Dual Inverter Controller V1-2a1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
1: length 124.9
  TOP w0.381: UT38.11 214.36,94.29 214.74,93.91 v1(214.74,93.63) 215.08,93.29 RT228.2 ; DT9.3 v1(220.56,97.14) ; LT27.2 220.22,103.26 CT154.2 v1(221.69,103.12) ; UT38.15 214.77,99.37 215.22,99.82 CT155.2 CT151.2 v1(218.69,99.82)
  GND1 w0.381: JT3.5 228.14,106.26 ; JT3.5 227.43,104.65 ; JT3.5 228.33,105.55 ; JT3.5 226.71,106.26 ; JT3.5 226.52,105.55 ; JT3.5 226.71,104.83 ; JT3.5 228.14,104.83 ; JT3.5 227.43,106.45 ; JT3.3 228.14,100.72 ; JT3.3 228.33,100.01 ; JT3.3 228.14,99.29 ; JT3.3 227.43,99.11 ; JT3.3 226.71,100.72 ; JT3.3 226.71,99.29 ; JT3.3 226.52,100.01 ; JT3.3 227.43,100.91 ; 226.99,110.65 JT3.11 ; JT3.11 226.99,114.36 ; JT3.11 230.7,114.36 ; JT3.11 228.85,115.02 ; JT3.11 228.85,109.99 ; JT3.11 226.33,112.5 ; JT3.11 230.7,110.65 ; JT3.11 231.36,112.5 ; JT3.10 231.36,87.51 ; JT3.10 226.99,89.37 ; JT3.10 230.7,89.37 ; JT3.10 230.7,85.66 ; JT3.10 228.85,85 ; JT3.10 228.85,90.03 ; JT3.10 226.99,85.66 ; JT3.10 226.33,87.51
  PWR2 w0.381: JT3.3 227.43,100.91 ; JT3.3 226.71,99.29 ; JT3.3 226.71,100.72 ; JT3.3 228.14,100.72 ; JT3.3 227.43,99.11 ; JT3.3 226.52,100.01 ; JT3.3 228.14,99.29 ; JT3.3 228.33,100.01 ; JT3.10 231.36,87.51 ; JT3.10 230.7,89.37 ; JT3.10 226.99,89.37 ; JT3.10 228.85,85 ; JT3.10 226.33,87.51 ; JT3.10 230.7,85.66 ; JT3.10 226.99,85.66 ; JT3.10 228.85,90.03 ; 226.33,112.5 JT3.11 ; JT3.11 231.36,112.5 ; JT3.11 230.7,114.36 ; JT3.11 226.99,110.65 ; JT3.11 226.99,114.36 ; JT3.11 230.7,110.65 ; JT3.11 228.85,115.02 ; JT3.11 228.85,109.99 ; 227.43,104.65 JT3.5 ; JT3.5 226.71,106.26 ; JT3.5 227.43,106.45 ; JT3.5 228.14,106.26 ; JT3.5 226.71,104.83 ; JT3.5 226.52,105.55 ; JT3.5 228.33,105.55 ; JT3.5 228.14,104.83
CANA-H: length 18
  TOP w0.381: UT38.14 214.74,98.1 215.1,97.75 215.84,97.75 216.17,97.42 216.71,97.42 217.23,97.94 RT224.1 218.18,98.08 DT9.1 221.79,98.08 222.46,97.4 225.44,97.4 226.65,98.62 JT3.7
CANA-L: length 14.9
  TOP w0.381: JT3.2 226.28,97.24 225.89,96.85 222.46,96.85 221.82,96.2 DT9.2 218.18,96.2 RT224.2 217.23,96.34 216.71,96.86 215.94,96.86 215.61,97.19 215.1,97.19 214.74,96.83 UT38.13
CANA-RX: length 109.9
  TOP w0.381: JT26.80 120.83,48.92 121.24,49.34 121.24,50.43 171.6,100.78 171.6,102.53 v1(172.04,102.97) ; UT38.5 197.16,100.64 194.65,103.16 190.18,103.16 190.17,103.17 v1(189.35,103.17)
  BOTTOM w0.381: v1(172.04,102.97) 172.24,103.17 v1(189.35,103.17)
CANA-TX: length 109.3
  TOP w0.381: v1(189.35,102.38) 190.17,102.38 190.18,102.4 194.35,102.4 198.64,98.1 UT38.7 ; v1(172.59,102.41) 172.59,100.96 121.83,50.2 121.83,49.13 121.64,48.94 JT26.82
  BOTTOM w0.381: v1(172.59,102.41) 188.65,102.41 188.68,102.38 v1(189.35,102.38)
CASE-TEMP: length 58.3
  TOP w0.381: JT26.30 97.64,50.31 92.44,55.51 90.92,55.51 87.28,59.14 v1(86.19,59.14)
  LAYER3 w0.381: v1(86.19,59.14) 86.19,59.76 81.34,64.61 81.34,72.6 77.12,76.82 v1(77.12,91.73)
  BOTTOM w0.381: RB26.2 CB11.1 77.12,92.45 77.12,92.45 v1(77.12,91.73)
COS-A: length 111.5
  TOP w0.381: JT26.36 100.02,54.48 101.73,56.19 v1(103.09,56.19) ; CT54.1 JT20.1
  TOP w0.508: CT54.1 RT99.2
  LAYER3 w0.381: JT20.1 187.57,70.2 184.31,66.94 184.31,62.49 178.01,56.19 v1(103.09,56.19)
COS-A-N: length 26.8
  TOP w0.381: JT18.6 225.39,74.66 224.22,74.66 220.13,70.57 218.14,70.57 217.17,69.6 215.24,69.6 214.64,70.2 DT13.3 213.9,70.2 213.87,70.18 213.32,70.18 212.92,70.57 210.04,70.57 209.52,70.05 RT95.1
  TOP w0.508: RT95.1 CT53.1 207.16,70.07 RT96.1 205.67,68.59 CT57.2 RT100.1
COS-A-P: length 23.8
  TOP w0.381: JT18.5 225.24,75.22 223.99,75.22 219.9,71.13 218.2,71.13 217.81,71.52 217.1,71.52 217.08,71.5 DT13.6 215.95,72.11 213.9,72.11 212.92,71.13 210.04,71.13 209.52,71.65 RT95.2
  TOP w0.508: RT93.1 207.1,71.57 CT53.2 RT95.2
COS-B: length 99.9
  TOP w0.381: CT72.1 JT27.1 ; v1(103.18,54.46) 102.45,53.73 102.45,48.66 102.44,48.65 JT26.42
  TOP w0.508: CT72.1 RT121.2
  LAYER3 w0.381: JT27.1 179.38,55.17 178.67,54.45 156.34,54.45 156.19,54.6 103.94,54.6 103.8,54.46 v1(103.18,54.46)
COS-B-N: length 26.2
  TOP w0.381: RT117.1 209.52,55.02 210.04,55.54 212.86,55.54 213.25,55.15 213.87,55.15 213.89,55.17 DT10.3 215.13,55.17 215.69,54.61 217.12,54.61 217.81,55.29 219.33,55.29 222.26,58.23 225.32,58.23 JT22.6
  TOP w0.508: RT122.1 CT75.2 205.67,53.56 RT119.1 207.16,55.04 CT71.1 RT117.1
COS-B-P: length 23.2
  TOP w0.381: JT22.5 225.32,58.78 222.03,58.78 219.34,56.1 218.19,56.1 217.79,56.49 217.1,56.49 217.08,56.47 DT10.6 216.34,56.47 215.78,57.03 213.79,57.03 212.86,56.1 210.04,56.1 209.52,56.62 RT117.2
  TOP w0.508: RT115.1 207.1,56.54 CT71.2 RT117.2
CURRENT-U: length 90
  TOP w0.381: JT11.1 127.85,110.63 127.9,110.68 RT50.2 ; JT26.12 90.42,48.77 v1(90.41,48.78)
  LAYER3 w0.508: JT11.1 127.85,78.01 110.55,60.71 100.05,60.71 90.41,51.08 v1(90.41,48.78)
  BOTTOM w0.381: v1(90.41,48.78) 90.41,49 89.96,49.45 88.56,49.45 87.01,51 CB55.1
CURRENT-U_N: length 63.8
  TOP w0.381: RT14.1 128.68,123.25 RT4.2
  TOP w0.508: 181.45,136.61 177.33,136.61 176.19,137.75 135.53,137.75 129.13,131.35 129.13,126.21 128.68,125.75 RT4.2
CURRENT-U_P: length 61.9
  TOP w0.381: RT4.1 130.28,123.25 RT15.1
  TOP w0.508: 178.91,132.8 178.91,133.46 175.31,137.06 135.81,137.06 129.82,131.07 129.82,126.21 130.28,125.75 RT4.1
CURRENT-V: length 94.3
  TOP w0.381: JT4.1 139.96,110.63 140.02,110.68 RT51.2 ; v1(91.23,48.78) 91.24,48.77 JT26.14
  LAYER3 w0.508: v1(91.23,48.78) 91.23,50.35 100.39,59.51 111.47,59.51 139.96,88 JT4.1
  BOTTOM w0.381: v1(91.23,48.78) 91.23,49.4 90.61,50.02 89.74,50.02 88.76,51 CB56.1
CURRENT-V_N: length 52.4
  TOP w0.381: RT5.2 140.84,123.25 RT16.1
  TOP w0.508: v1(173.57,134.68) 173.12,134.68 172.56,135.24 145.18,135.24 141.49,131.54 141.49,125.47 RT5.2
  BOTTOM w0.508: JB1.5 180.69,134.83 180.69,135.25 179.41,136.53 175.42,136.53 v1(173.57,134.68)
CURRENT-V_P: length 47.6
  TOP w0.381: RT17.1 142.44,123.25 RT5.1
  TOP w0.508: v1(172.63,133.74) 172.63,134.19 172.27,134.55 145.47,134.55 142.17,131.26 142.17,125.21 142.12,125.16 142.12,125.14 RT5.1
  BOTTOM w0.508: v1(172.63,133.74) 174.03,133.74 175.62,135.34 178.91,135.34
CURRENT-W: length 98.7
  TOP w0.381: JT26.18 92.84,48.76 v1(92.83,48.77) ; JT12.1 152.16,110.65 152.19,110.68 RT52.2
  LAYER3 w0.508: v1(92.83,48.77) 92.83,50.35 100.71,58.23 112.2,58.23 142.96,88.98 142.96,95.06 152.16,104.25 JT12.1
  BOTTOM w0.381: CB57.1 90.51,51 91.87,49.64 92.45,49.64 92.83,49.26 v1(92.83,48.77)
CURRENT-W_N: length 33.9
  TOP w0.381: RT6.2 153.01,123.25 RT18.1
  TOP w0.508: RT6.2 153.5,125.31 153.5,126.89 158.22,131.61 178.69,131.61 178.77,131.53 JB1.7
CURRENT-W_P: length 30.5
  TOP w0.381: RT19.1 154.61,123.25 RT6.1
  TOP w0.508: RT6.1 154.19,125.25 154.19,126.6 158.51,130.92 178.41,130.92 178.91,130.41 178.91,130.25
CURRENT-X: length 65.7
  TOP w0.381: JT26.26 96.04,48.76 v1(96.03,48.77)
  TOP w0.508: RT171.2 JT40.1
  LAYER3 w0.508: v1(96.03,48.77) 96.03,48.08 96.88,47.23 106.92,47.23 113.03,41.12 120.17,41.12 120.91,40.37 126.5,40.37 127.52,39.35 143.32,39.35 145.95,36.72 JT40.1
  BOTTOM w0.381: CB60.1 95.75,50.21 96.03,49.93 v1(96.03,48.77)
CURRENT-X_N: length 43.4
  TOP w0.381: JB5.7 153.65,7.12 147.12,13.66 RT213.2 147.12,19.92 RT210.1
CURRENT-X_P: length 42.9
  TOP w0.381: RT209.1 145.52,19.92 RT213.1 146.18,18.35 146.3,18.23 146.3,17.69 146.52,17.48 146.54,17.48 146.56,17.46 146.56,13.43 153.42,6.57 177.05,6.57 177.76,5.86 178.91,5.86
CURRENT-Y: length 55.4
  TOP w0.381: JT26.24 95.22,48.75 v1(95.21,48.77)
  TOP w0.508: RT170.2 JT39.1
  LAYER3 w0.508: JT39.1 128.75,36.72 126.12,39.35 120.66,39.35 119.66,40.35 112.53,40.35 106.55,46.34 95.77,46.34 95.21,46.9 v1(95.21,48.77)
  BOTTOM w0.381: CB59.1 94.02,51 95.21,49.81 v1(95.21,48.77)
CURRENT-Y_N: length 61.9
  TOP w0.381: JB5.5 183.14,7.97 183.14,6.59 180.6,4.05 148.73,4.05 138.44,14.33 136.79,14.33 134.95,16.17 RT212.2 134.95,19.92 RT208.1
CURRENT-Y_P: length 68.5
  TOP w0.381: 178.91,10.94 181.78,10.94 183.7,9.01 183.7,6.36 180.84,3.49 148.5,3.49 138.21,13.78 136.56,13.78 134.39,15.94 134.39,17.48 134.35,17.48 133.48,18.35 RT212.1 133.35,19.92 RT207.1
CURRENT-Z: length 44.7
  TOP w0.381: JT26.20 93.62,48.76 v1(93.62,48.77)
  TOP w0.508: RT169.2 JT38.1
  LAYER3 w0.508: v1(93.62,48.77) 93.62,47.22 95.39,45.45 106.2,45.45 107.16,44.48 107.16,44.47 112.04,39.59 118.52,39.59 121.39,36.72 JT38.1
  BOTTOM w0.381: CB58.1 92.27,51 93.62,49.65 v1(93.62,48.77)
CURRENT-Z_N: length 63.7
  TOP w0.381: v1(136.53,12.02) 136.19,11.67 130.09,11.67 123.86,17.89 123.16,17.89 122.78,18.27 RT211.2 122.78,19.92 RT206.1
  BOTTOM w0.381: v1(136.53,12.02) 136.88,11.67 175.52,11.67 176.03,12.17 178.83,12.17 178.86,12.2 JB5.3
CURRENT-Z_P: length 63.9
  TOP w0.381: RT205.1 121.18,19.92 RT211.1 121.31,18.35 122.18,17.48 122.78,17.48 122.93,17.33 123.63,17.33 129.85,11.11 136.19,11.11 v1(136.53,10.76) ; 178.91,8.48 JB5.6
  BOTTOM w0.381: JB5.6 176.2,11.11 136.88,11.11 v1(136.53,10.76)
EMUI: length 59.3
  TOP w0.381: JT17.14 67.45,88.38 65.95,86.88 65.95,71.47 68,69.43 74.08,69.43 75.23,68.28 75.23,65.07 77.71,62.59 77.71,51.54 79.86,49.39 84.26,49.39 85.33,48.32 85.33,46.19 85.87,45.65 JT26.1
EMUO: length 58.6
  TOP w0.381: JT26.2 86.44,48.65 85.07,50.02 80.12,50.02 78.34,51.8 78.34,62.85 75.86,65.33 75.86,68.54 74.34,70.06 68.26,70.06 66.58,71.74 66.58,86.34 67.4,87.16 69.78,87.16 JT17.13
EXC-A-N: length 60.5
  TOP w0.254: CT158.2 RT233.2 216.26,36.21 UT41.9
  TOP w0.381: JT18.2 232.59,74.95 236.9,74.95 237.42,74.43 238.5,74.43 DT15.3 ; CT158.2 219.35,36 v1(219.6,36.25)
  LAYER3 w0.381: JT18.2 231.39,72.57 234.5,69.46 234.5,56.83 228.26,50.59 223.96,50.59 221.86,48.49 221.86,40.23 220.24,38.61 220.24,36.89 v1(219.6,36.25)
EXC-A-P: length 63.1
  TOP w0.254: CT157.2 RT230.2 216.27,38.81 UT41.13
  TOP w0.381: DT15.6 240.1,76.31 237.96,76.31 237.16,75.51 232.16,75.51 JT18.1 ; CT157.2 219.36,39.02 v1(219.6,39.26)
  LAYER3 w0.381: v1(219.6,39.26) 220.1,39.26 221.3,40.46 221.3,48.72 223.73,51.15 228.03,51.15 233.94,57.06 233.94,69.23 230.13,73.04 230.13,75.03 JT18.1
EXC-B-N: length 32.1
  TOP w0.254: UT43.9 216.47,44.87 RT244.2 CT166.2
  TOP w0.381: DT12.3 238.13,57.79 238.11,57.77 237.09,57.77 236.64,58.23 233.52,58.23 232.53,57.23 JT22.2 ; v1(219.73,44.67) CT166.2
  LAYER3 w0.381: v1(219.73,44.67) 220.57,45.51 220.57,49.51 223.03,51.97 226.55,51.97 231.39,56.81 JT22.2
EXC-B-P: length 34.1
  TOP w0.254: UT43.13 216.47,47.47 RT237.2 CT162.2
  TOP w0.381: JT22.1 232.53,59.77 233.52,58.78 236.58,58.78 237.45,59.65 239.73,59.65 240.29,59.09 DT12.6 ; v1(219.9,47.97) 219.61,47.69 CT162.2
  LAYER3 w0.381: JT22.1 230.14,58.53 230.14,56.35 226.32,52.53 222.79,52.53 219.88,49.62 219.88,47.99 v1(219.9,47.97)
GLOBAL-FAULT-ALL: length 64.5
  TOP w0.381: JT26.134 162.7,58.14 161.66,59.19 v1(160.72,59.19) ; v1(168.16,78.19) 168.16,80.5 173.82,86.17 185.25,86.17 187.46,83.96 JT16.1
  LAYER3 w0.381: v1(160.72,59.19) 161.34,59.19 168.16,66.01 v1(168.16,78.19)
  BOTTOM w0.381: v1(160.72,59.19) 159.6,60.31 UB17.4
GLOBAL-FAULT-UVW: length 22.7
  TOP w0.381: JT26.130 v1(161.1,57.69)
  BOTTOM w0.381: 159.6,63.76 UB17.3 ; 159.6,63.76 160.13,64.29 161.76,64.29 162.8,63.25 162.8,59.38 v1(161.1,57.69) ; 159.6,63.76 UB15.4
GLOBAL-FAULT-XYZ: length 26.4
  TOP w0.381: v1(160.59,58.36) 161.53,58.36 161.91,57.98 v1(161.91,48.83) 161.91,47.67 JT26.132
  BOTTOM w0.381: v1(160.59,58.36) 159.32,58.36 157.69,59.99 UB17.6 ; v1(161.91,48.83) 159.8,46.72 159.8,41.42 159.06,40.69 UB20.4
I2CA-SCL: length 91.2
  TOP w0.381: v1(124,49.2) 124,50.01 175.51,101.52 175.51,106 175.64,106.12 RT54.1 175.64,107.76 175.3,108.1 JT2.9 ; v1(124.03,44.4) JT26.87
  BOTTOM w0.381: v1(124,49.2) 124,45.05 124.03,45.02 v1(124.03,44.4)
I2CA-SDA: length 93.9
  TOP w0.381: v1(123.24,44.4) JT26.85 ; JT2.10 174.04,114.12 174.04,108.48 173.5,107.95 RT53.1 173.5,100.3 173.02,99.82 172.88,99.82 123.29,50.22 v1(123.29,49.6)
  BOTTOM w0.381: v1(123.24,44.4) 123.24,49.55 v1(123.29,49.6)
LED-G: length 20
  TOP w0.381: RT154.1 v1(178.34,39.51) ; v1(163.61,43.39) 162.7,44.3 JT26.133
  BOTTOM w0.381: v1(163.61,43.39) 165.32,41.69 176.15,41.69 v1(178.34,39.51)
LED-R: length 16.5
  TOP w0.381: RT152.1 v1(172.88,39.51) ; JT26.129 161.1,43.64 v1(162.48,42.26)
  BOTTOM w0.381: v1(162.48,42.26) 164.65,40.09 172.29,40.09 v1(172.88,39.51)
LED-Y: length 18.3
  TOP w0.381: RT153.1 v1(175.61,39.51) ; v1(163.06,42.84) 161.92,43.98 JT26.131
  BOTTOM w0.381: v1(175.61,39.51) 174.21,40.9 164.99,40.9 v1(163.06,42.84)
PWM7A: length 116.5
  TOP w0.381: JT26.58 112.04,54.17 119.14,61.27 124.28,61.27 160.46,97.45 160.46,116.72 164.65,120.91 v1(177.28,120.91)
  LAYER3 w0.381: v1(177.28,120.91) 177.84,120.35 JT2.12
PWM7B: length 116.5
  TOP w0.381: v1(176.57,119.92) 175.94,119.92 175.59,120.28 164.92,120.28 161.09,116.46 161.09,97.19 124.55,60.64 119.62,60.64 112.83,53.85 JT26.60
  LAYER3 w0.381: v1(176.57,119.92) 176.57,119.05 176.58,119.03 176.58,114.09 JT2.11
PWM8A: length 113.7
  TOP w0.381: JT2.14 180.38,117.31 178.66,119.02 164.56,119.02 161.73,116.19 161.73,96.92 124.78,59.98 120.11,59.98 113.64,53.51 JT26.62
PWM8B: length 113.9
  TOP w0.381: JT26.64 114.43,53.22 120.48,59.28 124.98,59.28 162.36,96.66 162.36,115.93 164.82,118.39 177.94,118.39 179.09,117.24 179.09,114.12 JT2.13
PWM9A: length 55.2
  TOP w0.381: JT26.167 v1(176.32,44.29) ; v1(182.28,80.4) 182.25,80.4 176.32,74.46 v1(176.32,50.12) ; RT66.1 v1(183.54,93.72)
  BOTTOM w0.381: v1(183.54,93.72) 182.28,92.46 v1(182.28,80.4) ; v1(176.32,50.12) v1(176.32,44.29)
PWM9B: length 44.7
  TOP w0.381: JT26.168 176.32,49.01 177.07,49.77 177.07,74.02 182.74,79.69 182.84,79.69 v1(183.3,80.15) ; v1(183.3,87.69) 183.96,87.69 184.13,87.85 RT75.1
  BOTTOM w0.381: v1(183.3,80.15) v1(183.3,87.69)
QEA_A: length 71.5
  TOP w0.381: v1(119.4,51.45) 118.76,50.81 118.35,50.81 118.35,50.81 117.64,50.81 116.03,49.2 JT26.68
  BOTTOM w0.381: UB22.3 169.97,31.11 167.49,33.58 155.74,33.58 149.18,40.14 123.63,40.14 119.03,44.74 119.03,51.09 v1(119.4,51.45)
QEA_B: length 68.9
  TOP w0.381: v1(119.9,50.63) 119.27,50 117.98,50 116.84,48.86 JT26.70
  BOTTOM w0.381: UB22.4 170.24,31.76 167.76,34.23 155.88,34.23 149.41,40.7 123.86,40.7 119.59,44.97 119.59,49.92 119.71,50.05 119.71,50.06 119.9,50.25 v1(119.9,50.63)
QEA_I: length 65.4
  TOP w0.381: v1(120.39,49.78) 119.75,49.14 118.93,49.14 118.44,48.65 JT26.74
  BOTTOM w0.381: UB22.5 170.5,32.41 168.03,34.88 156.02,34.88 149.64,41.26 124.1,41.26 120.15,45.2 120.15,48.92 120.39,49.16 v1(120.39,49.78)
QEB_A: length 56.5
  TOP w0.381: JT26.100 128.83,48.59 131.02,50.78 v1(147.58,50.78)
  BOTTOM w0.381: UB22.6 170.77,33.06 168.3,35.53 156.16,35.53 147.58,44.11 v1(147.58,50.78)
QEB_B: length 54.2
  TOP w0.381: v1(148.26,50.11) 131.43,50.11 129.64,48.32 JT26.102
  BOTTOM w0.381: v1(148.26,50.11) 148.26,49.44 148.22,49.4 148.22,44.37 156.41,36.18 168.57,36.18 171.04,33.71 UB22.7
QEB_I: length 51.4
  TOP w0.381: v1(148.93,49.44) 133.92,49.44 133.91,49.45 132.04,49.45 131.24,48.65 JT26.106
  BOTTOM w0.381: UB22.8 171.31,34.36 168.84,36.83 156.66,36.83 148.85,44.63 148.85,48.69 148.93,48.76 v1(148.93,49.44)
QEPA-A-IN: length 20.2
  TOP w0.381: RT186.2 CT118.1 191.13,27.53 190.43,26.83 JT41.1
  BOTTOM w0.381: JT41.1 185.25,25.43 183.12,25.43 181.32,27.24 181.32,29.45 179,31.76 UB22.21
QEPA-B-IN: length 20.9
  TOP w0.381: JT41.2 184.11,25.28 185.18,24.21 191.1,24.21 191.15,24.27 RT194.2 CT131.1
  BOTTOM w0.381: JT41.2 182.9,26.83 181.97,27.77 181.97,29.72 179.27,32.41 UB22.20
QEPA-I-IN: length 18.6
  TOP w0.381: RT172.2 CT116.1 191.13,29.15 190.91,29.37 JT41.3
  BOTTOM w0.381: UB22.19 179.54,33.06 182.62,29.99 182.62,29.09 183.59,28.11 185.39,28.11 JT41.3
QEPB-A-IN: length 17
  TOP w0.381: CT106.1 RT166.2 191.15,32.41 190.38,33.18 185.38,33.18 JT41.6
  BOTTOM w0.381: JT41.6 182.61,31.91 180.81,33.71 UB22.18
QEPB-B-IN: length 17
  TOP w0.381: RT156.2 CT99.1 190.58,35.66 189.37,34.45 JT41.7
  BOTTOM w0.381: UB22.17 181.08,34.36 182.25,33.19 185.39,33.19 JT41.7
QEPB-I-IN: length 17.5
  TOP w0.381: JT41.8 185.37,35.71 187.95,35.71 191.15,38.91 RT148.2 CT91.1
  BOTTOM w0.381: UB22.16 181.35,35.01 181.91,34.45 JT41.8
RSLV-A-PWM: length 17
  TOP w0.381: RT163.1 189.25,45.23 188.19,44.17 182.48,44.17 181.85,43.54 178.2,43.54 177.1,44.64 JT26.169
RSLV-B-PWM: length 16.7
  TOP w0.381: RT242.1 179.16,50.74 177.1,48.68 JT26.170
SD-C1: length 91.8
  TOP w0.381: v1(129.64,52.92) 129.64,52.93 182.92,106.2 JT2.15 ; JT26.101 v1(129.64,44.38)
  BOTTOM w0.381: v1(129.64,44.38) v1(129.64,52.92)
SD-C2: length 92.2
  TOP w0.381: JT26.105 v1(131.24,44.38) ; JT2.17 185.46,106.48 131.24,52.26 v1(131.24,52.25)
  BOTTOM w0.381: v1(131.24,44.38) v1(131.24,52.25)
SD-C3: length 92.6
  TOP w0.381: v1(132.84,51.6) 132.84,51.6 188,106.76 JT2.19 ; JT26.109 v1(132.84,44.38)
  BOTTOM w0.381: v1(132.84,44.38) v1(132.84,51.6)
SD-D1: length 94.7
  TOP w0.381: JT2.16 182.92,114.61 181.66,113.36 181.66,106.09 128.83,53.26 v1(128.83,53.25) ; JT26.99 v1(128.83,44.38)
  BOTTOM w0.381: v1(128.83,44.38) v1(128.83,53.25)
SD-D2: length 95.1
  TOP w0.381: JT26.103 v1(130.43,44.38) ; JT2.18 184.2,114.12 184.2,106.37 130.43,52.6 v1(130.43,52.59)
  BOTTOM w0.381: v1(130.43,44.38) v1(130.43,52.59)
SD-D3: length 95.4
  TOP w0.381: JT26.107 v1(132.03,44.38) ; v1(132.03,51.93) 132.03,51.94 186.74,106.65 186.74,114.12 JT2.20
  BOTTOM w0.381: v1(132.03,44.38) v1(132.03,51.93)
SHUTDOWN+15V: length 59
  TOP w0.381: v1(220.16,34.57) 221.44,34.57 RT160.1 RT161.1 ; JT26.155 171.46,45.6 v1(171.46,44.23)
  LAYER3 w0.381: v1(220.16,34.57) 218.2,32.6 195.8,32.6 185.5,42.91 v1(175.32,42.91)
  BOTTOM w0.381: v1(171.46,44.23) 171.46,43.47 172.02,42.91 v1(175.32,42.91)
SIN-A: length 119.3
  TOP w0.381: v1(103.03,56.97) 101.55,56.97 99.24,54.66 JT26.34 ; CT45.1 JT19.1
  TOP w0.508: CT45.1 RT83.2
  LAYER3 w0.381: v1(103.03,56.97) 177.65,56.97 183.5,62.82 183.5,73.74 187.47,77.71 JT19.1
SIN-A-N: length 30.4
  TOP w0.381: JT18.4 227.58,75.01 227.58,77.26 226.76,78.09 218.2,78.09 217.22,77.1 215.03,77.1 DT14.3 214.4,77.69 213.22,77.69 212.82,78.09 210.04,78.09 209.52,77.56 RT80.1
  TOP w0.508: RT80.1 CT44.1 207.16,77.59 RT81.1 205.67,76.1 CT49.2 RT91.1
SIN-A-P: length 25.5
  TOP w0.381: RT80.2 209.52,79.16 210.04,78.64 212.84,78.64 213.77,79.57 215.4,79.57 215.96,79.01 DT14.6 217.11,79.01 217.14,79.04 217.69,79.04 218.09,78.64 226.99,78.64 228.85,76.79 JT18.3
  TOP w0.508: RT80.2 CT44.2 207.1,79.09 RT79.1
SIN-B: length 104.2
  TOP w0.381: v1(103.18,55.41) 102.56,55.41 101.62,54.47 JT26.40 ; CT63.1 JT23.1
  TOP w0.508: CT63.1 RT105.2
  LAYER3 w0.381: v1(103.18,55.41) 115.5,55.41 115.52,55.43 178.53,55.43 185.78,62.68 JT23.1
SIN-B-N: length 31.2
  TOP w0.381: RT102.1 209.52,62.53 210.04,63.05 212.78,63.05 213.18,62.66 213.87,62.66 213.9,62.68 DT11.3 214.64,62.68 215.2,62.12 217.23,62.12 218.18,63.08 225.58,63.08 227.5,61.16 227.5,58.58 JT22.4
  TOP w0.508: RT102.1 CT61.1 207.16,62.56 RT103.1 205.67,61.07 CT67.2 RT113.1
SIN-B-P: length 26.5
  TOP w0.381: RT102.2 209.52,64.13 210.04,63.61 212.78,63.61 213.82,64.65 216.08,64.65 216.55,64.18 DT11.6 216.64,64.07 217.69,64.07 218.12,63.64 225.81,63.64 228.85,60.61 JT22.3
  TOP w0.508: RT102.2 CT61.2 207.1,64.06 RT101.1
SPIA-CLK: length 97.7
  TOP w0.381: JT2.6 171.47,114.12 171.47,111.3 168.34,108.16 168.34,99.29 121.78,52.73 117.83,52.73 v1(117.26,52.16) ; JT26.71 v1(117.63,44.38)
  BOTTOM w0.381: v1(117.63,44.38) 117.63,45 117.26,45.37 v1(117.26,52.16)
SPIA-MISO: length 94.8
  TOP w0.381: JT2.5 170.22,111.63 167.78,109.19 167.78,99.59 121.53,53.34 116.98,53.34 v1(116.47,52.83) ; JT26.69 v1(116.84,44.38)
  BOTTOM w0.381: v1(116.84,44.38) 116.7,44.52 116.7,44.66 116.47,44.89 v1(116.47,52.83)
SPIA-MOSI: length 94.5
  TOP w0.381: JT26.67 v1(116.03,44.38) ; v1(115.66,53.5) 116.1,53.94 121.32,53.94 166.87,99.5 166.87,110.61 167.68,111.41 JT2.3
  BOTTOM w0.381: v1(116.03,44.38) 115.66,44.75 v1(115.66,53.5)
SPIA-STE: length 96
  TOP w0.381: JT26.73 v1(118.44,44.38) ; v1(118.07,51.48) 118.76,52.17 122.01,52.17 168.89,99.06 168.89,99.11 169.04,99.25 v1(169.04,107.81)
  BOTTOM w0.381: JT2.4 168.93,114.12 168.93,109.88 168.98,109.83 168.98,108.48 169.04,108.43 v1(169.04,107.81) ; v1(118.07,51.48) 118.07,45.37 118.44,45 v1(118.44,44.38)
TCK: length 54.6
  TOP w0.381: v1(73.72,68.61) 73.72,64.78 76.44,62.06 76.44,51.01 79.31,48.14 82.46,48.14 83.6,47 83.6,44.94 84.92,43.62 87.46,43.62 88.04,44.19 JT26.5
  BOTTOM w0.381: JT17.11 JT17.9 72.67,81.63 72.67,75.53 73.72,74.48 v1(73.72,68.61)
TDI: length 38.8
  TOP w0.381: JT26.8 88.82,49.44 86.34,51.93 80.91,51.93 80.25,52.59 80.25,63.64 77.77,66.12 77.77,69.29 72.98,74.07 72.6,74.07 JT17.3
TDO: length 46.9
  TOP w0.381: JT26.6 88.04,49.12 85.86,51.29 80.65,51.29 79.61,52.33 79.61,63.38 77.13,65.86 77.13,69.07 74.87,71.33 70.47,71.33 69.68,72.12 69.68,79.43 JT17.7
TMS: length 40.8
  TOP w0.381: v1(74.39,67.45) 74.39,65 77.07,62.32 77.07,51.27 79.54,48.8 83.93,48.8 84.54,48.19 84.54,45.09 85.35,44.28 86.89,44.28 87.22,44.61 JT26.3
  BOTTOM w0.381: JT17.1 72.32,71.81 72.32,68.84 73.72,67.45 v1(74.39,67.45)
TRST: length 38.9
  TOP w0.381: JT26.4 87.22,48.78 85.35,50.66 80.38,50.66 78.98,52.06 78.98,63.11 76.5,65.6 76.5,68.8 74.6,70.7 69.89,70.7 68.46,72.12 JT17.2
U-FAULT: length 112.3
  TOP w0.381: JT26.122 157.9,57.4 157.69,57.61 v1(157.69,70.32) ; v1(103.77,115.5) 103.17,114.91 UT8.3
  LAYER3 w0.381: v1(114.54,99.04) 116.39,100.9 116.39,111.62 112.51,115.5 v1(103.77,115.5)
  BOTTOM w0.381: UB15.1 v1(157.69,70.32) 157.69,70.94 145.22,83.41 127.63,83.41 114.54,96.5 v1(114.54,99.04)
U-FAULT-N: length 46
  TOP w0.381: LT12.1 107.96,112.33 108.57,112.94 109.34,112.94 111.7,115.3 111.7,131.17 111.81,131.28 111.81,131.68 111.95,131.81 111.95,132.37 v1(112.03,132.45)
  BOTTOM w0.381: JB4.8 95.4,139.49 95.4,136.65 99.03,133.02 110.97,133.02 111.54,132.45 v1(112.03,132.45)
U-FAULT-N-FILTER: length 5.4
  TOP w0.381: RT49.2 102.58,112.42 101.9,113.09 101.62,113.09 101.1,113.61 UT8.1
  TOP w0.508: RT49.2 CT27.2 105.33,112.42 LT12.2
U-FAULT-P: length 41.8
  TOP w0.381: v1(111.14,131.56) 111.14,115.53 109.11,113.5 108.57,113.5 107.96,114.11 LT9.1
  BOTTOM w0.381: v1(111.14,131.56) 111.14,132.06 110.74,132.46 98.8,132.46 94.11,137.15 JB4.7
U-FAULT-P-FILTER: length 5
  TOP w0.381: RT49.1 102.38,114.26 UT8.2
  TOP w0.508: LT9.2 104.11,114.11 CT27.1 RT49.1
U-LEN: length 129
  LAYER3 w0.381: v1(118.3,124.91) 115.74,124.91 105.36,135.29 100.49,135.29 100.09,134.9 99.07,134.9 98.67,135.29 87.84,135.29 86.49,136.64 JB4.13
  BOTTOM w0.381: v1(118.3,124.91) 118.3,123.96 118.26,123.92 118.26,97.84 128.91,87.2 147.88,87.2 165.1,69.98 UB18.12
U-LEN-OUT: length 11.9
  TOP w0.381: JT26.144 v1(166.72,48.88)
  BOTTOM w0.381: UB18.8 165.75,53.61 166.72,52.64 v1(166.72,48.88)
U-OCEN: length 130.4
  LAYER3 w0.381: JB4.15 83.95,136.63 85.93,134.66 98.52,134.66 98.84,134.34 100.32,134.34 100.64,134.66 105.09,134.66 115.52,124.24 v1(117.63,124.24)
  BOTTOM w0.381: v1(117.63,124.24) 117.63,118.74 117.61,118.73 117.61,97.57 128.64,86.55 147.61,86.55 164.45,69.71 UB18.11
U-OCEN-OUT: length 11.8
  TOP w0.381: JT26.142 v1(165.9,48.88)
  BOTTOM w0.381: UB18.9 165.1,53.34 165.9,52.53 v1(165.9,48.88)
U-PSDIS: length 127.4
  LAYER3 w0.381: v1(118.97,125.58) 115.97,125.58 105.62,135.93 100.33,135.93 99.86,135.45 99.3,135.45 98.83,135.93 90.13,135.93 89.03,137.02 JB4.11
  BOTTOM w0.381: v1(118.97,125.58) 118.97,124.63 118.89,124.54 118.89,98.13 129.18,87.85 148.15,87.85 165.75,70.25 UB18.13
U-PSDIS-OUT: length 12
  TOP w0.381: JT26.146 v1(167.5,48.88)
  BOTTOM w0.381: UB18.7 166.4,53.88 167.5,52.77 v1(167.5,48.88)
U-RTD: length 106
  TOP w0.381: UT8.5 101.79,116.21 101.8,116.2 102.06,116.2 v1(102.5,115.76) ; v1(107.99,72.58) 107.15,73.41 102.5,73.41 93.71,82.2 92.8,82.2 87.49,87.51 v1(86.52,87.51) ; JT26.92 v1(125.63,48.93)
  LAYER3 w0.381: v1(92.64,103.89) 92.64,112.33 94.27,113.95 94.27,114.08 94.65,114.46 95.81,114.46 97.39,116.05 98.84,116.05 99.13,115.76 v1(102.5,115.76)
  BOTTOM w0.254: UB3.2 84.9,90.37 84.51,89.98 84.51,88.78 85.21,88.08 RB32.1
  BOTTOM w0.381: 86.57,87.56 85.55,87.56 RB32.1 ; 86.57,87.56 v1(86.52,87.51) ; 86.57,87.56 87.92,88.91 87.92,97.39 92.64,102.12 v1(92.64,103.89) ; v1(125.63,48.93) 125.63,50.72 107.99,68.36 v1(107.99,72.58)
U-RTD-N: length 42.6
  TOP w0.381: LT3.1 107.96,118.8 108.57,118.19 109.11,118.19 109.49,118.58 109.49,136.63 103.65,142.47 92.28,142.47 91.35,141.53 91.35,140.99 JB4.10
U-RTD-N-FILTER: length 5.5
  TOP w0.381: UT8.7 101.42,117.51 101.9,117.99 101.9,118.04 102.58,118.72 RT32.2
  TOP w0.508: LT3.2 104.11,118.8 CT20.2 RT32.2
U-RTD-P: length 48.5
  TOP w0.381: LT6.1 107.96,117.03 108.57,117.64 109.34,117.64 110.05,118.34 110.05,136.86 103.88,143.03 92.05,143.03 90.32,141.29 90.32,139.49 JB4.9
U-RTD-P-FILTER: length 5
  TOP w0.381: RT32.1 102.37,116.86 UT8.6
  TOP w0.508: LT6.2 104.11,117.03 CT20.1 RT32.1
U-TEMP: length 29.5
  TOP w0.381: JT26.25 96.01,45.63 v1(96.01,44.41)
  BOTTOM w0.381: v1(96.01,44.41) 96.01,45.82 98.54,48.34 98.54,53.52 95.1,56.96 90.77,56.96 86.22,61.5 CB48.1 RB66.2
UHS-PWM: length 113
  TOP w0.381: RT20.1 v1(105.38,122.07) ; v1(105.64,44.1) JT26.49 ; v1(105.64,51.06) 105.64,62.18 117.35,73.89 117.35,85.87 104.03,99.18 94.54,99.18 93.74,99.98 v1(93.74,101.08)
  BOTTOM w0.381: v1(105.38,122.07) 105.38,112.67 107.4,110.65 JT9.1 107.4,106.17 104.49,103.26 95.3,103.26 93.74,101.7 v1(93.74,101.08) ; v1(105.64,51.06) v1(105.64,44.1)
UHS-PWM-N: length 26.1
  TOP w0.381: UT1.3 105.33,125.12 106.44,126.22 106.44,131.81 103.52,134.73 100.97,134.73 v1(99.58,136.13)
  BOTTOM w0.381: JB4.4 100.45,139.51 100.45,137.71 99.7,136.96 99.7,136.25 v1(99.58,136.13)
UHS-PWM-P: length 23.8
  TOP w0.381: JB4.3 99.19,137.65 101.06,135.78 103.25,135.78 106.99,132.04 106.99,125.99 105.52,124.51 101.58,124.51 101.54,124.47 UT1.2
ULS-PWM: length 130.5
  TOP w0.381: v1(106.43,44.1) JT26.51 ; v1(106.43,51.06) 106.43,61.86 118.13,73.57 118.13,86.2 104.36,99.97 94.9,99.97 94.52,100.35 v1(94.52,101.08) ; RT3.1 103.9,131.17 v1(103.64,131.43)
  BOTTOM w0.381: v1(94.52,101.08) 95.92,102.47 109.8,102.47 113.5,106.17 JT10.1 113.5,112.43 109.61,116.31 109.61,125.46 v1(103.64,131.43) ; v1(106.43,51.06) v1(106.43,44.1)
ULS-PWM-N: length 25.4
  TOP w0.381: UT1.5 102,126.42 102.05,126.46 104.89,126.46 105.85,127.43 105.85,131.6 103.56,133.89 99.2,133.89 97.91,135.18 97.91,139.51 JB4.6
ULS-PWM-P: length 21.7
  TOP w0.381: JB4.5 96.65,135.64 98.97,133.33 103.33,133.33 105.29,131.37 105.29,127.66 104.66,127.02 102.05,127.02 102,127.07 UT1.6
V-FAULT: length 123.7
  TOP w0.381: JT26.124 158.71,57.74 158.7,57.75 158.7,63.74 159.38,64.42 v1(159.38,70.05) ; v1(93.23,116.39) 93.7,116.86 UT8.11
  LAYER3 w0.381: v1(115.35,98.37) 115.79,98.81 115.8,98.81 117.31,100.32 117.31,112.5 112.75,117.06 93.9,117.06 v1(93.23,116.39)
  BOTTOM w0.381: UB15.3 159.6,69.83 v1(159.38,70.05) 145.21,84.22 127.97,84.22 115.35,96.84 v1(115.35,98.37)
V-FAULT-N: length 41.3
  TOP w0.381: JB3.8 65.55,139.49 65.55,135.74 67.35,133.94 81.37,133.94 85.46,129.86 85.46,119.87 86.36,118.96 86.9,118.96 87.51,119.57 LT1.1
V-FAULT-N-FILTER: length 5.4
  TOP w0.381: RT30.2 92.9,119.48 93.83,118.54 93.86,118.54 94.25,118.16 UT8.9
  TOP w0.508: RT30.2 CT18.2 90.14,119.48 LT1.2
V-FAULT-P: length 39.7
  TOP w0.381: LT4.1 87.51,117.79 86.9,118.4 86.13,118.4 84.9,119.63 84.9,129.63 81.14,133.38 67.11,133.38 64.99,135.5 64.99,137.85 64.61,138.23 JB3.7
V-FAULT-P-FILTER: length 5
  TOP w0.381: RT30.1 93.1,117.62 93.54,117.62 93.65,117.51 UT8.10
  TOP w0.508: LT4.2 90.14,117.88 CT18.1 RT30.1
V-LEN: length 159.2
  LAYER3 w0.381: v1(120.24,122.58) 115.38,122.58 104.57,133.39 100.96,133.39 100.78,133.22 82.67,133.22 81.1,134.79 58.5,134.79 56.65,136.64 JB3.13
  BOTTOM w0.381: UB18.15 167.05,70.79 148.69,89.15 129.71,89.15 120.21,98.65 120.21,121.6 120.24,121.62 v1(120.24,122.58)
V-LEN-OUT: length 12.4
  TOP w0.381: JT26.152 v1(169.92,48.88)
  BOTTOM w0.381: v1(169.92,48.88) 169.92,52.23 167.7,54.45 UB18.5
V-OCEN: length 160.7
  LAYER3 w0.381: JB3.15 54.11,136.51 56.47,134.15 80.83,134.15 82.33,132.66 101.01,132.66 101.11,132.76 104.31,132.76 115.16,121.9 v1(119.56,121.9)
  BOTTOM w0.381: v1(119.56,121.9) 119.56,98.38 129.45,88.5 148.42,88.5 166.4,70.52 UB18.14
V-OCEN-OUT: length 12.3
  TOP w0.381: JT26.150 v1(169.1,48.88)
  BOTTOM w0.381: v1(169.1,48.88) 169.1,52.12 167.05,54.18 UB18.6
V-PSDIS: length 157.8
  LAYER3 w0.381: JB3.11 59.19,136.64 60.4,135.42 81.36,135.42 82.76,134.03 98.36,134.03 98.6,133.78 100.55,133.78 100.8,134.03 104.83,134.03 115.61,123.25 v1(120.91,123.25)
  BOTTOM w0.381: UB18.16 167.7,71.06 148.96,89.8 129.98,89.8 120.86,98.92 120.86,122.25 120.91,122.3 v1(120.91,123.25)
V-PSDIS-OUT: length 12.5
  TOP w0.381: JT26.154 v1(170.7,48.88)
  BOTTOM w0.381: UB18.4 168.35,54.72 170.7,52.36 v1(170.7,48.88)
V-RTD: length 93.3
  TOP w0.381: v1(91.96,116.14) 92.54,115.56 UT8.13 ; v1(96.66,86.9) 96.66,82.3 104.85,74.1 107.9,74.1 108.8,73.2 v1(108.8,72.58) ; JT26.94 v1(126.44,48.93)
  LAYER3 w0.381: v1(96.66,86.9) 94.02,89.54 94.02,93.2 91.96,95.26 v1(91.96,116.14)
  BOTTOM w0.254: UB4.2 95.07,90.37 94.68,89.98 94.68,88.78 95.39,88.08 RB33.1
  BOTTOM w0.381: v1(96.66,86.9) 96.66,87.52 96.28,87.9 RB33.1 ; v1(108.8,72.58) 108.8,68.7 126.44,51.05 v1(126.44,48.93)
V-RTD-N: length 49.8
  TOP w0.381: JB3.10 60.47,139.51 60.47,137.71 61.17,137.01 61.17,136.15 65.06,132.27 80.68,132.27 83.78,129.16 83.78,115.8 86.01,113.57 86.78,113.57 87.39,112.96 LT11.1
V-RTD-N-FILTER: length 5.5
  TOP w0.381: UT8.15 93.93,114.26 93.44,113.78 93.44,113.73 92.77,113.05 RT48.2
  TOP w0.508: LT11.2 90.01,113.05 CT26.2 RT48.2
V-RTD-P: length 45.6
  TOP w0.381: JB3.9 61.73,136.38 65.29,132.82 80.91,132.82 84.34,129.4 84.34,116.03 86.24,114.13 86.78,114.13 87.39,114.74 LT8.1
V-RTD-P-FILTER: length 5
  TOP w0.381: UT8.14 93.54,114.91 93.28,114.65 RT48.1
  TOP w0.508: LT8.2 90.01,114.65 CT26.1 RT48.1
V-TEMP: length 27
  TOP w0.381: v1(96.82,44.41) JT26.27
  BOTTOM w0.381: CB49.1 RB67.2 89.47,61.53 89.52,61.48 89.52,61.4 92.9,58.02 95.18,58.02 99.12,54.09 99.12,47.78 96.82,45.48 v1(96.82,44.41)
V_U+: length 6.1
  TOP w0.635: RT55.1 JT43.12
V_U-: length 6.1
  BOTTOM w0.635: RB19.1 JT43.11
V_V+: length 6.1
  TOP w0.635: RT67.1 JT43.10
V_V-: length 6.1
  BOTTOM w0.635: RB41.1 JT43.9
V_W+: length 6.1
  TOP w0.635: RT84.1 JT43.8
V_W-: length 6.1
  BOTTOM w0.635: RB59.1 JT43.7
V_X+: length 6.1
  TOP w0.635: RT106.1 JT43.6
V_X-: length 6.1
  BOTTOM w0.635: RB74.1 JT43.5
V_Y+: length 6.1
  TOP w0.635: RT130.1 JT43.4
V_Y-: length 6.1
  BOTTOM w0.635: RB83.1 JT43.3
V_Z+: length 6.1
  TOP w0.635: RT174.1 JT43.2
V_Z-: length 6.1
  BOTTOM w0.635: JT43.1 RB103.1
VDC-M: length 2.9
  TOP w0.635: 14.36,116.19 13.34,116.19 13.34,116.19 JT1.2
VDC-P: length 2.9
  TOP w0.635: JT1.1 14.36,124.19
VHS-PWM: length 112.5
  TOP w0.381: v1(90.05,129.78) 91.06,129.78 RT2.1 ; JT7.1 95.21,104.98 99.25,100.95 104.53,100.95 118.95,86.53 118.95,73.23 107.24,61.52 107.24,50.36 v1(107.55,50.05) ; v1(109.56,50.05) 109.79,49.82 109.79,45.32 108.62,44.15 107.59,44.15 107.24,44.51 JT26.53
  BOTTOM w0.381: v1(90.05,129.78) 90.05,116.7 95.21,111.54 JT7.1 ; v1(109.56,50.05) v1(107.55,50.05)
VHS-PWM-N: length 35.3
  TOP w0.381: UT1.11 93.4,127.07 93.35,127.11 89.13,127.11 87.34,128.91 87.34,131.07 82.46,135.95 70.42,135.95 v1(69.86,136.51)
  BOTTOM w0.381: v1(69.86,136.51) 70.24,136.89 70.24,137.34 70.61,137.71 70.61,139.51 JB3.4
VHS-PWM-P: length 31.2
  TOP w0.381: JB3.3 71.07,136.51 82.69,136.51 87.89,131.3 87.89,129.14 89.36,127.67 93.35,127.67 93.4,127.72 UT1.10
VLS-PWM: length 95.5
  TOP w0.381: RT13.1 v1(91.48,121.37) ; JT8.1 101.31,105.28 119.73,86.86 119.73,72.9 108.03,61.19 108.03,50.64 108.89,49.78 108.89,45.95 108.59,45.65 JT26.55
  BOTTOM w0.381: v1(91.48,121.37) 95.13,117.71 95.13,113.65 98.18,110.6 99.9,110.6 101.31,109.19 JT8.1
VLS-PWM-N: length 37.4
  TOP w0.381: JB3.6 68.07,139.51 68.07,136.65 69.66,135.06 81.83,135.06 86.57,130.32 86.57,127.92 88.77,125.72 93.35,125.72 93.4,125.77 UT1.13
VLS-PWM-P: length 35.5
  TOP w0.381: JB3.5 66.81,137.12 69.43,134.5 81.6,134.5 86.01,130.09 86.01,127.69 88.54,125.16 93.35,125.16 93.4,125.12 UT1.14
VSENSE-DC: length 46.8
  TOP w0.381: v1(87.49,57.39) 89.93,54.95 89.93,52.18 91.96,50.15 96.06,50.15 96.82,49.39 v1(96.82,48.77) 96.82,48.76 JT26.28
  LAYER3 w0.381: v1(87.49,57.39) 75.65,57.39 73.11,59.93 73.11,65.57 72.15,66.53 JT21.1
  BOTTOM w0.381: v1(96.82,48.77) 96.82,49.39 97.51,50.07 CB61.1 ; RB65.2 JT21.1
VSENSE-U: length 40.6
  TOP w0.381: JT26.9 89.61,45.63 v1(89.61,44.36)
  LAYER3 w0.381: v1(89.61,44.36) 89.61,44.98 89.22,45.37 80.15,45.37 74.94,50.58 74.94,56.12 72.3,58.76 72.3,61.04 71.77,61.58 JT24.1
  BOTTOM w0.381: RB72.2 JT24.1 ; CB62.1 87.01,42.06 88.16,43.21 89.09,43.21 89.61,43.73 v1(89.61,44.36)
VSENSE-V: length 36.8
  TOP w0.381: JT26.11 90.4,45.63 v1(90.4,44.37)
  LAYER3 w0.381: JT25.1 71.38,56.62 73.67,54.34 73.67,50.35 80.45,43.57 90.09,43.57 90.4,43.87 v1(90.4,44.37)
  BOTTOM w0.381: v1(90.4,44.37) 90.4,43.7 88.76,42.06 CB63.1 ; RB73.2 JT25.1
VSENSE-W: length 34.9
  TOP w0.381: JT26.15 92.05,45.63 v1(92.05,44.38)
  LAYER3 w0.381: JT28.1 71.11,51.67 80,42.78 85.55,42.78 85.58,42.76 89.56,42.76 89.59,42.78 91.36,42.78 92.05,43.47 v1(92.05,44.38)
  BOTTOM w0.381: v1(92.05,44.38) 92.05,43.59 90.51,42.06 CB64.1 ; RB80.2 JT28.1
VSENSE-X: length 34.2
  TOP w0.381: v1(92.84,44.4) JT26.17
  LAYER3 w0.381: v1(92.84,44.4) 92.84,42.99 91.74,41.89 77.86,41.89 73.03,46.72 JT29.1
  BOTTOM w0.381: CB65.1 92.27,42.06 92.84,42.63 v1(92.84,44.4) ; RB81.2 JT29.1
VSENSE-Y: length 34.5
  TOP w0.381: v1(94.44,44.4) JT26.21
  LAYER3 w0.381: JT30.1 72.4,41.77 73.16,41 92.45,41 94.44,42.99 v1(94.44,44.4)
  BOTTOM w0.381: CB66.1 94,42.97 94.44,43.41 v1(94.44,44.4) ; RB82.2 JT30.1
VSENSE-Z: length 36.9
  TOP w0.381: v1(95.22,44.38) JT26.23
  LAYER3 w0.381: JT31.1 71.77,36.81 75.19,40.24 92.85,40.24 95.22,42.62 v1(95.22,44.38)
  BOTTOM w0.381: CB67.1 95.75,43.23 95.22,43.76 v1(95.22,44.38) ; RB89.2 JT31.1
W-FAULT: length 157.9
  TOP w0.381: UT4.3 71.7,116.91 v1(71.1,116.31) ; JT26.126 159.5,63.75 160.27,64.52 v1(160.27,70.23)
  LAYER3 w0.381: v1(71.1,116.31) 71.1,117.2 74.71,120.81 91.08,120.81 91.2,120.7 93.25,120.7 93.36,120.81 111.13,120.81 118.35,113.6 118.35,99.9 116.59,98.14 116.58,98.14 v1(116.14,97.7)
  BOTTOM w0.381: v1(116.14,97.7) 116.14,97.16 128.29,85.01 145.49,85.01 v1(160.27,70.23) 160.27,67.94 160.08,67.75 158.54,67.75 157.69,66.9 UB15.6
W-FAULT-N: length 45.2
  TOP w0.381: LT2.1 66.91,119.49 66.69,119.27 66.15,119.27 51.72,133.7 37.11,133.7 35.19,135.62 35.19,136.51 35.68,137 35.68,139.51 JB2.8
W-FAULT-N-FILTER: length 5.4
  TOP w0.381: RT31.2 72.3,119.4 73.11,118.59 73.39,118.59 73.78,118.21 UT4.1
  TOP w0.508: RT31.2 CT19.2 70.76,119.49 LT2.2
W-FAULT-P: length 43.3
  TOP w0.381: LT5.1 66.91,117.71 51.49,133.14 36.88,133.14 34.63,135.39 34.63,138.02 JB2.7
W-FAULT-P-FILTER: length 5
  TOP w0.381: RT31.1 73.01,117.8 73.25,117.56 UT4.2
  TOP w0.508: RT31.1 CT19.1 70.76,117.71 LT5.2
W-LEN: length 195.3
  LAYER3 w0.381: JB2.13 26.8,135.07 29.05,132.82 80.28,132.82 81.68,131.43 102.69,131.43 103.36,130.75 104.43,130.75 114.88,120.31 121.08,120.31 121.08,120.3 v1(122.26,120.3)
  BOTTOM w0.381: v1(122.26,120.3) 122.26,119.35 122.26,119.35 122.26,99.5 130.56,91.19 152.14,91.19 177.06,66.27 UB19.17
W-LEN-OUT: length 13.1
  TOP w0.381: JT26.162 v1(173.9,48.88)
  BOTTOM w0.381: v1(173.9,48.88) 173.9,51.04 174.99,52.12 174.99,55.38 177.71,58.09 UB19.3
W-OCEN: length 196.3
  LAYER3 w0.381: JB2.15 24.26,136.08 28.15,132.19 80.02,132.19 81.42,130.79 102.53,130.79 103.13,130.2 104.09,130.2 114.66,119.63 v1(121.59,119.63)
  BOTTOM w0.381: v1(121.59,119.63) 121.59,118.75 121.61,118.73 121.61,99.23 130.29,90.54 152,90.54 176.41,66.13 UB19.16
W-OCEN-OUT: length 13.1
  TOP w0.381: JT26.160 v1(173.12,48.88)
  BOTTOM w0.381: v1(173.12,48.88) 173.12,51.17 174.34,52.39 174.34,55.6 177,58.26 177,58.91 177.02,58.93 177.02,59.13 UB19.4
W-PSDIS: length 193.3
  LAYER3 w0.381: JB2.11 29.34,136 31.89,133.46 80.55,133.46 81.94,132.06 103.33,132.06 103.36,132.1 103.98,132.1 115.11,120.98 v1(122.94,120.98)
  BOTTOM w0.381: UB19.18 177.71,66.41 152.28,91.84 130.83,91.84 122.91,99.77 122.91,120 122.94,120.02 v1(122.94,120.98)
W-PSDIS-OUT: length 13
  TOP w0.381: JT26.164 v1(174.72,48.88)
  BOTTOM w0.381: v1(174.72,48.88) 174.72,50.93 175.64,51.85 175.64,55.17 178.36,57.88 UB19.2
W-RTD: length 103.4
  TOP w0.381: JT26.96 v1(127.23,48.93) ; UT4.5 75.47,115.61 77.89,113.19 77.89,106.69 80.45,104.12 82.99,104.12 90.79,96.33 100.7,96.33 104.48,92.54 104.48,89.19 v1(106.74,86.93)
  BOTTOM w0.254: RB34.1 105.56,88.08 104.86,88.78 104.86,89.98 105.24,90.37 UB5.2
  BOTTOM w0.381: v1(127.23,48.93) 127.23,51.38 109.59,69.02 109.59,73.57 106.61,76.54 106.61,86.18 106.74,86.3 v1(106.74,86.93) 106.74,87.56 106.4,87.9 RB34.1
W-RTD-N: length 53.5
  TOP w0.381: JB2.10 30.63,139.51 30.63,136.09 34.76,131.96 50.89,131.96 65.36,117.48 65.36,114.94 66.07,114.23 66.51,114.23 67.08,113.66 67.29,113.66 67.68,113.28 LT10.1
W-RTD-N-FILTER: length 5.4
  TOP w0.381: RT47.2 72.3,113.1 73.5,114.31 UT4.7
  TOP w0.508: RT47.2 CT25.2 70.76,113.01 LT10.2
W-RTD-P: length 48.5
  TOP w0.381: LT7.1 66.3,114.79 65.92,115.17 65.92,117.71 51.12,132.52 34.99,132.52 31.88,135.62 JB2.9
W-RTD-P-FILTER: length 5
  TOP w0.381: RT47.1 72.67,114.7 72.92,114.96 UT4.6
  TOP w0.508: RT47.1 CT25.1 70.76,114.79 LT7.2
W-TEMP: length 24.4
  TOP w0.381: JT26.31 98.42,44.39 v1(98.44,44.37)
  BOTTOM w0.381: v1(98.44,44.37) 98.44,45.51 99.86,46.92 99.86,54.37 92.73,61.5 CB50.1 RB68.2
WHS-PWM: length 118.5
  TOP w0.381: RT1.1 v1(77.1,131.17) ; JT26.50 105.64,48.97 103.89,50.72 103.89,62.72 115.73,74.56 115.73,85.2 103.37,97.57 92.22,97.57 85.76,104.02 85.76,106.44 85.36,106.84 85.36,106.85 84.73,107.48 84.72,107.48 84.52,107.68 JT5.1
  BOTTOM w0.381: v1(77.1,131.17) 75.45,129.52 74.94,129.52 74.56,129.14 74.56,112.38 79.26,107.68 JT5.1
WHS-PWM-N: length 43.6
  TOP w0.381: UT2.3 72.95,126.94 72.86,127.03 60.75,127.03 52.42,135.37 41.03,135.37 v1(39.89,136.51)
  BOTTOM w0.381: JB2.4 40.76,139.51 40.76,137.71 40.51,137.46 40.51,137.13 v1(39.89,136.51)
WHS-PWM-P: length 39.6
  TOP w0.381: UT2.2 60.98,127.59 52.65,135.93 41.26,135.93 40.9,136.29 40.9,136.83 JB2.3
WLS-PWM: length 107.6
  TOP w0.381: JT26.52 106.43,49.07 104.78,50.71 104.78,62.54 116.49,74.25 116.49,85.52 103.68,98.33 92.55,98.33 89.12,101.76 JT6.1 89.12,108.69 89.04,108.77 89.04,109.71 87.39,111.36 85.73,111.36 82.69,114.41 82.69,121.01 82.43,121.27 79.26,121.27 78.75,120.76 RT28.1
WLS-PWM-N: length 46.3
  TOP w0.381: UT2.5 72.95,125.64 72.86,125.55 61.45,125.55 52.18,134.81 38.92,134.81 37.98,135.75 37.98,136.76 38.22,137 38.22,139.51 JB2.6
WLS-PWM-P: length 44.2
  TOP w0.381: JB2.5 37.42,137.77 37.42,135.51 38.68,134.25 51.95,134.25 61.21,124.99 UT2.6
X-FAULT: length 73.6
  TOP w0.381: v1(103.85,19.11) 103.25,18.51 UT35.3 ; v1(152.19,35.76) 157.9,41.47 v1(157.9,43.8) JT26.121
  LAYER3 w0.381: v1(110.68,23.81) 110.68,25.59 119.03,33.94 150.38,33.94 v1(152.19,35.76)
  BOTTOM w0.381: v1(157.9,43.8) 157.9,43.78 157.16,43.04 UB20.1 ; v1(110.68,23.81) 105.97,19.11 v1(103.85,19.11)
X-FAULT-N: length 29
  TOP w0.381: JB8.8 90.32,5.49 90.32,7.39 94.39,11.46 106.84,11.46 108.61,13.23 108.61,15.72 107.76,16.57 107.66,16.57 107.27,16.19 LT25.1
X-FAULT-N-FILTER: length 5.4
  TOP w0.381: UT35.1 101.17,17.21 101.69,16.69 101.98,16.69 102.65,16.02 RT216.2
  TOP w0.508: LT25.2 105.41,16.02 CT144.2 RT216.2
X-FAULT-P: length 26.5
  TOP w0.381: LT22.1 107.27,17.51 107.66,17.13 107.99,17.13 109.17,15.95 109.17,13 107.07,10.91 94.62,10.91 91.57,7.85 JB8.7
X-FAULT-P-FILTER: length 5
  TOP w0.381: UT35.2 102.46,17.86 RT216.1
  TOP w0.508: RT216.1 CT144.1 104.19,17.71 LT22.2
X-LEN: length 70.2
  TOP w0.381: v1(154.03,15.24) 154.03,21.67 155.75,23.39 UT27.12
  LAYER3 w0.381: JB8.13 102.07,9.65 113.05,9.65 119.92,16.52 123.89,16.52 125.17,15.24 v1(154.03,15.24)
X-LEN-OUT: length 18.7
  TOP w0.381: UT27.8 156.4,33.02 166.72,43.34 JT26.143
X-OCEN: length 67.6
  TOP w0.381: v1(153.35,14.51) 153.35,21.91 155.1,23.65 UT27.11
  LAYER3 w0.381: JB8.15 103.94,8.97 113.33,8.97 120.32,15.96 123.66,15.96 125.11,14.51 v1(153.35,14.51)
X-OCEN-OUT: length 18.6
  TOP w0.381: JT26.141 165.9,43.34 155.75,33.18 UT27.9
X-PSDIS: length 72.9
  TOP w0.381: UT27.13 156.4,23.15 154.7,21.45 v1(154.7,15.91)
  LAYER3 w0.381: v1(154.7,15.91) 125.29,15.91 124.12,17.08 119.53,17.08 112.77,10.32 100.21,10.32 JB8.11
X-PSDIS-OUT: length 18.7
  TOP w0.381: JT26.145 167.5,43.26 157.05,32.81 UT27.7
X-RTD: length 117
  TOP w0.381: v1(86.57,73.12) 82.52,69.07 v1(82.52,61.71) ; v1(110.83,29.5) 116.14,34.81 116.14,35.82 123.95,43.63 124.23,43.63 124.84,44.24 JT26.89 ; UT35.5 101.87,19.81 101.88,19.8 102.14,19.8 v1(102.58,19.36)
  LAYER3 w0.381: v1(110.83,29.5) 109.29,27.96 109.29,27.48 104.71,22.89 104.71,21.49 v1(102.58,19.36) 99.94,19.36 96.33,22.97 88.88,22.97 77.91,33.95 77.91,36.37 77.3,36.98 v1(77.3,38.46)
  BOTTOM w0.254: UB9.2 84.9,76.11 84.51,75.72 84.51,74.52 85.21,73.82 RB50.1
  BOTTOM w0.381: RB50.1 86.05,73.64 v1(86.57,73.12) ; v1(82.52,61.71) 77.3,56.5 v1(77.3,38.46)
X-RTD-N: length 32.8
  TOP w0.381: LT16.1 108.5,22.41 110.51,20.39 110.51,12.69 106.64,8.82 96.78,8.82 95.37,7.41 95.37,5.49 JB8.10
X-RTD-N-FILTER: length 5.5
  TOP w0.381: UT35.7 101.5,21.11 101.98,21.59 101.98,21.64 102.65,22.32 RT204.2
  TOP w0.508: LT16.2 104.19,22.41 CT135.2 RT204.2
X-RTD-P: length 28.9
  TOP w0.381: LT19.1 108.04,20.63 108.34,20.94 109.18,20.94 109.95,20.16 109.95,12.92 106.41,9.38 96.55,9.38 94.11,6.94 JB8.9
X-RTD-P-FILTER: length 5
  TOP w0.381: UT35.6 102.45,20.46 RT204.1
  TOP w0.508: LT19.2 104.19,20.63 CT135.1 RT204.1
X-TEMP: length 24
  TOP w0.381: v1(99.23,44.39) 99.24,44.4 JT26.33
  BOTTOM w0.381: RB69.2 CB51.1 95.98,60.07 101.18,54.87 101.18,53.4 101.53,53.05 101.53,47.31 99.23,45.02 v1(99.23,44.39)
XHS-PWM: length 27.2
  TOP w0.381: JT26.54 v1(107.24,48.78)
  TOP w0.508: RT190.1 v1(105.04,24.91)
  BOTTOM w0.381: JT36.1 107.4,39.47 107.24,39.63 v1(107.24,48.78)
  BOTTOM w0.508: v1(105.04,24.91) 107.54,27.41 107.54,35.59 107.4,35.73 JT36.1
XHS-PWM-N: length 36.9
  TOP w0.381: UT25.3 101.59,27.96 101.8,28.17 102.26,28.17 102.31,28.22 102.68,28.22 v1(102.68,28.5)
  BOTTOM w0.381: v1(102.68,28.5) 102.68,28.01 98.55,23.87 94.42,23.87 85.24,14.69 85.24,6.25 86.49,4.99 JB8.4
XHS-PWM-P: length 34.3
  TOP w0.381: UT25.2 101.73,27.31 102.03,27.61 v1(103.57,27.61)
  BOTTOM w0.381: v1(103.57,27.61) 103.08,27.61 98.78,23.31 94.66,23.31 85.8,14.45 85.8,8.17 86.49,7.47 JB8.3
XLS-PWM: length 28.9
  TOP w0.381: JT26.56 v1(108.03,48.78)
  TOP w0.508: RT168.1 104.74,33.02 105.86,34.15 112.91,34.15 113.5,34.73 JT37.1
  BOTTOM w0.381: v1(108.03,48.78) 108.03,41.83 110.55,39.3 112.52,39.3 113.5,38.32 JT37.1
XLS-PWM-N: length 39.3
  TOP w0.381: v1(103.58,29.21) 103.4,29.4 102.16,29.4 102.02,29.26 UT25.5
  BOTTOM w0.381: v1(103.58,29.21) 104.49,28.31 104.49,27.12 103.64,26.27 103.64,23.73 100.72,20.81 100.72,15.6 98.94,13.83 93.23,13.83 87.75,8.35 87.75,5.51 JB8.6
XLS-PWM-P: length 38.3
  TOP w0.381: v1(104.47,30.1) 104.32,29.95 100.61,29.95 UT25.6
  BOTTOM w0.381: v1(104.47,30.1) 104.47,29.94 104.26,29.73 104.26,29.33 105.05,28.54 105.05,26.89 104.2,26.04 104.2,23.5 101.28,20.58 101.28,15.37 99.17,13.27 93.46,13.27 88.31,8.12 88.31,7.49 JB8.5
Y-FAULT: length 86.7
  TOP w0.381: UT35.11 93.77,20.46 v1(93.3,19.99) ; v1(152.76,35.18) 158.69,41.11 158.69,43.16 158.73,43.2 v1(158.73,43.82) 158.73,44.45 158.71,44.47 JT26.123
  LAYER3 w0.381: v1(93.3,19.99) 93.31,18.25 94.13,17.43 106.46,17.43 111.49,22.46 111.49,25.25 118.73,32.49 150.08,32.49 v1(152.76,35.18)
  BOTTOM w0.381: v1(158.73,43.82) 158.72,43.81 158.72,43.27 159.06,42.93 UB20.3
Y-FAULT-N: length 40.3
  TOP w0.381: LT14.1 87.84,23.17 84.05,19.38 84.05,15.98 80.62,12.56 65.29,12.56 60.47,7.74 60.47,6.47 60.46,6.46 60.46,5.5 JB7.8
Y-FAULT-N-FILTER: length 5.4
  TOP w0.381: RT196.2 92.97,23.08 93.91,22.15 93.94,22.15 94.32,21.76 UT35.9
  TOP w0.508: LT14.2 90.22,23.08 CT132.2 RT196.2
Y-FAULT-P: length 35.5
  TOP w0.381: JB7.7 61.73,8.21 65.52,12 80.86,12 84.61,15.75 84.61,19.15 86.85,21.39 LT17.1
Y-FAULT-P-FILTER: length 5
  TOP w0.381: RT196.1 93.18,21.23 93.61,21.23 93.73,21.11 UT35.10
  TOP w0.508: RT196.1 CT132.1 90.22,21.48 LT17.2
Y-LEN: length 100.6
  TOP w0.381: v1(156.05,17.26) 156.05,20.79 157.7,22.44 UT27.15
  LAYER3 w0.381: v1(156.05,17.26) 125.52,17.26 124.58,18.19 118.74,18.19 112.22,11.67 74.25,11.67 JB7.13
Y-LEN-OUT: length 19.2
  TOP w0.381: JT26.151 169.92,44.02 158.35,32.46 UT27.5
Y-OCEN: length 97.9
  TOP w0.381: v1(155.37,16.58) 155.37,21.11 157.05,22.78 UT27.14
  LAYER3 w0.381: v1(155.37,16.58) 125.41,16.58 124.35,17.64 119.14,17.64 112.5,10.99 76.11,10.99 JB7.15
Y-OCEN-OUT: length 19.1
  TOP w0.381: JT26.149 169.1,44.07 157.7,32.67 UT27.6
Y-PSDIS: length 104.2
  TOP w0.381: UT27.16 158.35,22.18 156.72,20.55 v1(156.72,17.93)
  LAYER3 w0.381: JB7.11 72.38,12.34 110.07,12.34 117.5,19.77 123.8,19.77 125.64,17.93 v1(156.72,17.93)
Y-PSDIS-OUT: length 19.3
  TOP w0.381: UT27.4 159,32.32 170.7,44.02 JT26.153
Y-RTD: length 131.8
  TOP w0.381: v1(96.4,72.86) 95.87,73.39 90.32,73.39 83.19,66.26 83.19,61.43 83.17,61.41 v1(83.17,61.19) ; JT26.91 125.63,44.19 124.51,43.07 124.5,43.07 116.93,35.5 116.93,34.48 v1(111.39,28.94) ; UT35.13 92.61,19.16 v1(92.03,19.74)
  LAYER3 w0.381: v1(111.39,28.94) 110.08,27.64 110.08,26.36 106.06,22.34 106.06,19.16 105.12,18.22 96.83,18.22 94.24,20.81 93.1,20.81 v1(92.03,19.74) 90.79,19.74 77.13,33.4 77.13,35.51 v1(76.29,36.36)
  BOTTOM w0.254: UB10.2 94.82,76.11 94.43,75.72 94.43,74.52 95.13,73.82 RB51.1
  BOTTOM w0.381: RB51.1 95.92,72.86 v1(96.4,72.86) ; v1(83.17,61.19) 78.29,56.32 78.29,38.36 v1(76.29,36.36)
Y-RTD-N: length 30.8
  TOP w0.381: JB7.10 65.53,5.49 65.53,8.45 67.3,10.22 80.86,10.22 87.2,16.57 LT24.1
Y-RTD-N-FILTER: length 5.5
  TOP w0.381: RT215.2 92.85,16.65 93.52,17.33 93.52,17.38 94,17.86 UT35.15
  TOP w0.508: RT215.2 CT143.2 90.09,16.65 LT24.2
Y-RTD-P: length 29.5
  TOP w0.381: LT21.1 88.09,18.34 80.53,10.78 67.07,10.78 64.65,8.36 64.65,7.15 JB7.9
Y-RTD-P-FILTER: length 5
  TOP w0.381: UT35.14 93.62,18.51 93.36,18.25 RT215.1
  TOP w0.508: RT215.1 CT143.1 90.09,18.25 LT21.2
Y-TEMP: length 22.5
  TOP w0.381: JT26.37 100.84,44.4 v1(100.83,44.39)
  BOTTOM w0.381: RB70.2 CB52.1 99.24,57.67 101.78,55.12 101.78,53.65 102.13,53.3 102.13,46.68 100.83,45.38 v1(100.83,44.39)
YHS-PWM: length 28.3
  TOP w0.381: JT26.57 112.04,44.51 110.23,42.71 v1(106.23,42.71)
  TOP w0.508: JT34.1 93.61,36.81 91.5,34.7 RT167.1
  BOTTOM w0.381: JT34.1 95.21,38.32 97.39,40.5 101.99,40.5 104.2,42.71 v1(106.23,42.71)
YHS-PWM-N: length 53.7
  TOP w0.381: UT25.11 94.84,29.95 94.28,29.95 94.25,29.91 90.42,29.91 82.36,21.85 82.36,17.79 79.31,14.74 63.08,14.74 57.91,9.57 57.91,5.49 JB7.4
YHS-PWM-P: length 51.8
  TOP w0.381: UT25.10 94.87,30.53 94.84,30.5 94.05,30.5 94.01,30.47 90.19,30.47 81.8,22.08 81.8,18.02 79.08,15.3 62.85,15.3 56.65,9.1 JB7.3
YLS-PWM: length 37.6
  TOP w0.381: v1(106.26,41.87) 110.27,41.87 112.83,44.42 JT26.59
  TOP w0.508: RT185.1 90.21,25.34 90.04,25.51 v1(89.42,25.51)
  BOTTOM w0.381: v1(106.26,41.87) 104.16,41.87 101.31,39.02 JT35.1
  BOTTOM w0.508: v1(89.42,25.51) 89.86,25.95 89.86,26.2 96.78,33.13 100.21,33.13 101.31,34.23 JT35.1
YLS-PWM-N: length 51.9
  TOP w0.381: UT25.13 94.87,28.58 94.84,28.55 94.05,28.55 94.01,28.52 90.27,28.52 82.94,21.19 82.94,17.12 79.83,14.02 64.34,14.02 v1(59.06,8.75)
  BOTTOM w0.381: JB7.6 57.93,5.49 57.93,7.61 v1(59.06,8.75)
YLS-PWM-P: length 47.6
  TOP w0.381: UT25.14 94.84,27.99 94.28,27.99 94.25,27.96 90.5,27.96 83.49,20.96 83.49,16.89 80.07,13.46 64.57,13.46 59.9,8.79 59.9,7.48 JB7.5
Z-FAULT: length 111.8
  TOP w0.381: v1(153.32,34.63) 156.61,37.92 156.72,37.92 v1(157.34,38.54) 157.34,38.64 159.5,40.81 JT26.125 ; v1(70.34,19.92) 70.93,20.52 UT34.3
  LAYER3 w0.381: v1(70.34,19.92) 72.59,17.67 93.01,17.43 93.72,16.72 106.86,16.72 112.28,22.14 112.28,24.93 119.06,31.71 150.4,31.71 v1(153.32,34.63)
  BOTTOM w0.381: UB20.6 157.16,39.61 157.34,39.43 v1(157.34,38.54)
Z-FAULT-N: length 46.5
  TOP w0.381: LT15.1 66.4,22.59 63.76,22.59 53.52,12.34 35.61,12.34 30.63,7.36 30.63,5.49 JB6.8
Z-FAULT-N-FILTER: length 5.4
  TOP w0.381: UT34.1 73.01,21.82 72.63,22.2 72.34,22.2 71.53,23.01 RT197.2
  TOP w0.508: RT197.2 CT133.2 70,23.1 LT15.2
Z-FAULT-P: length 42.4
  TOP w0.381: LT18.1 66.91,21.63 66.6,21.93 66.57,21.93 66.54,21.97 66.31,21.97 66.25,22.03 63.99,22.03 53.75,11.78 35.84,11.78 32.74,8.68 32.74,7.62 JB6.7
Z-FAULT-P-FILTER: length 5
  TOP w0.381: RT197.1 72.24,21.41 72.49,21.17 UT34.2
  TOP w0.508: RT197.1 CT133.1 70,21.32 LT18.2
Z-LEN: length 138.5
  TOP w0.381: UT28.17 167,23.65 164.16,20.81 159.27,20.81 158.82,20.36 v1(158.82,19.21)
  LAYER3 w0.381: JB6.13 46.32,13.59 109.45,13.59 117.06,21.19 156.84,21.19 v1(158.82,19.21)
Z-LEN-OUT: length 17
  TOP w0.381: JT26.161 173.9,43.87 167.65,37.61 UT28.3
Z-OCEN: length 135.5
  TOP w0.381: UT28.16 166.35,24.19 163.6,21.45 159.01,21.45 158.15,20.58 v1(158.15,18.54)
  LAYER3 w0.381: JB6.15 48.19,12.91 109.73,12.91 117.31,20.49 156.19,20.49 v1(158.15,18.54)
Z-OCEN-OUT: length 16.9
  TOP w0.381: UT28.4 167,37.76 173.12,43.87 JT26.159
Z-PSDIS: length 141.3
  TOP w0.381: UT28.18 167.65,23.22 164.31,19.88 v1(159.49,19.88)
  LAYER3 w0.381: v1(159.49,19.88) 157.53,21.85 116.85,21.85 109.2,14.2 44.4,14.2 JB6.11
Z-PSDIS-OUT: length 17.1
  TOP w0.381: UT28.2 168.3,37.47 174.72,43.89 JT26.163
Z-RTD: length 153.2
  TOP w0.381: JT26.93 126.44,43.86 117.74,35.16 117.74,34.15 v1(112.66,29.07) ; v1(71.86,19.67) 72.3,19.23 72.43,19.23 72.44,19.22 UT34.5 ; v1(106.51,72.63) 105.08,71.2 99.39,71.2 98.85,71.74 90.57,71.74 88.89,70.05 88.8,70.05 83.97,65.22 v1(83.97,60.6)
  LAYER3 w0.381: v1(85.86,27.67) 89.04,30.84 110.88,30.84 v1(112.66,29.07)
  BOTTOM w0.254: RB52.1 105.05,73.82 104.35,74.52 104.35,75.72 104.74,76.11 UB11.2
  BOTTOM w0.381: v1(85.86,27.67) 85.42,27.23 85.42,26.94 78.4,19.92 76.84,19.92 75.83,18.91 72.62,18.91 v1(71.86,19.67) 71.86,30.36 79.46,37.96 79.46,56.09 v1(83.97,60.6) ; v1(106.51,72.63) 106.07,72.63 RB52.1
